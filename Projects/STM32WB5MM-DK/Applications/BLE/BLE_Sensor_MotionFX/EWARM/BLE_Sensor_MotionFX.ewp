# IAR project BLE_Sensor_MotionFX.ewp, settings and files
configuration BLE_Sensor_MotionFX (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB5MMG ST STM32WB5MMG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB5Mxx; STM32WL55MM_DK
  ICCARM.CCIncludePath2: ../Core/Inc; ../Core/Src/vl53l0x; ../STM32_WPAN/App; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Utilities/sequencer; ../../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WB5MM-DK; ../../../../../../Drivers/BSP/Components/ssd1315; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Utilities/Fonts; ../../../../../../Utilities/LCD; ../../../../../../Drivers/BSP/Components/ism330dhcx; ../../../../../../Drivers/CMSIS/DSP/Source/FilteringFunctions; ../../../../../../Drivers/CMSIS/DSP/Include; ../../../../../../Drivers/BSP/Components/stts22h; ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc; ../../../../../../Drivers/BSP/blinkt
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Sensor_MotionFX.hex
  ILINK.IlinkOutputFile: BLE_Sensor_MotionFX.out
  ILINK.IlinkIcfFile: stm32wb5mxx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb5mxx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_debug.c app_entry.c app_led_bar_shield.c app_vl53l0x.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Application/User/Core/vl53l0x
    ../Core/Src/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c vl53l0x_tof.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c env_server_app.c motenv_server_app.c motion_server_app.c MotionFX_Manager.c motionfx_server_app.c p2p_server_app.c p2p_stm_demo.c wb5m_sensor_stm.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/blinkt
    ../../../../../../Drivers/BSP/blinkt/: blinkt.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STM32WB5MM-DK
    ../../../../../../Drivers/BSP/STM32WB5MM-DK/: stm32wb5mm_dk.c stm32wb5mm_dk_bus.c stm32wb5mm_dk_env_sensors.c stm32wb5mm_dk_env_sensors_ex.c stm32wb5mm_dk_lcd.c stm32wb5mm_dk_motion_sensors.c stm32wb5mm_dk_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_MotionFX_Library
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot.a
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Utilities
    ../../../../../../Utilities/LCD/: stm32_lcd.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
